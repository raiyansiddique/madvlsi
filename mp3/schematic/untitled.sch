v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/madvlsi/mp3/schematic/amp.sym} 60 0 0 0 {name=X1}
